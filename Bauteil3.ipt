# Autodesk Inventor part: Bauteil3
## iProperties
Created: 2005-12
Part Number: Bauteil3
Document SubType Name: Modeling
Designer: mp
Author: mp
## Feature names
1. Drehung1 [Revolution]
