# Autodesk Inventor assembly: IVNGWC-December05-mp
## iProperties
Created: 2005-12
Part Number: IVNGWC-December05-mp
Document SubType Name: Assembly
Designer: mp
Author: mp
